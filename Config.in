## Config.in
```kconfig
config BR2_PACKAGE_KORZENIEWSKIM_TIMER
    bool "korzeniewskim-timer"
    help
      Timer package.
```
